# Keil uVision project YumairFP01.uvprojx, settings and files
target MicroStation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YumairFP01 +hex
  AfterMake: xcopy Objects\*.hex Firmware /Y
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o Firmware/YumairFP01.bin Objects/YumairFP01.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,HAL_BOARD_NAME_BASIC,DEVICE_TYPE_YT201A
  c include: ..\..\hal;..\..\lib\inc;..\..\sys;..\..\usr;..\..\usr\USART_IO;..\..\usr\RTC;..\..\usr\FF11;..\..\usr\YumairLibrary;..\..\usr\DISPLAY;..\..\usr\Sensor\lite
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xbed0
  group Usr
    ../../usr/: main.c GPRS.c PowerManager.c GPRSPower.c APP.c Manufacture.c
    ../../usr/USART_IO/: usart_io.c delay.c
    ../../usr/RTC/: rtc.c
    ../../usr/FF11/: diskio.c ff.c sdio_sdcard.c sd_api.c
    ../../usr/DISPLAY/: ledpanel_hardware.c ledpanel_protocol.c
  group Hal
    ../../hal/: HalCommon.c HalUart.c HalGPIO.c HalTimer.c HalFlash.c HalWatchdog.c HalADC.c HalWait.c
  group Sys
    ../../sys/: Sys.c SysTimer.c SysCommand.c
  group HalLib
    ../../lib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_sdio.c stm32f10x_adc.c
  group YMLib
    ../../usr/YumairLibrary/: YMPropertyManager.c Yumair.c YumairProtocol.c YumairServer.c YumairOTA.c HTTPRequest.c MD5.c YMSocket.c
  group Sensor
    ../../usr/: Sensors.c SensorCom.c
    ../../usr/Sensor/basic/: CODSensor.c FLOWSensor.c MPSSensor.c SSSensor.c CHRMSensor.c BODSensor.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
